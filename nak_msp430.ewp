# IAR project nak_msp430.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 260
  General.GHeapSize2: 140
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: NO_NAK_
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5739.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group drivers
    ./: ports.c pwm.c sysclk.c timer.c uart.c
  group source
    ./: main.c proto.c utils.c
